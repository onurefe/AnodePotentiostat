# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER; HSE_VALUE=8000000; SYSCLK_FREQ=168000000
  ICCARM.CCIncludePath2: ..\Include\; ..\Libraries\CMSIS\Include; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Libraries\STM32_BlueNRG\Interface; ..\Libraries\STM32_BlueNRG\SimpleBlueNRG_HCI\includes
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group 1.Application
    ../Source/: device_manager.c main.c
  group 2.EIS
    ../Source/: eis.c eis_core.c
  group 2.Voltammetry
    ../Source/: amperometry.c voltammetry_core.c
  group 3.SerialProtocol
    ../Source/: characteristic_protocol.c characteristic_server.c packet_manager.c
  group 4.Middlewares
    ../Source/: alarm_clock.c crc32.c eeprom_emulator.c exception_handler.c queue.c queue_generic.c sys_time.c utils.c
  group 5.Board
    ../Source/: board.c board_bt_module.c
  group 6.HAL Adapter
    ../Source/: interrupts.c peripheral_init.c
  group 7.CMSIS
    ../Libraries/CMSIS/Source/: startup_stm32f40xx.s system_stm32f4xx.c
  group 7.HAL
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
